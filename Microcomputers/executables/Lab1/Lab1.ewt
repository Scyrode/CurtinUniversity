<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>MSP430</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>MSP430</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <file>
    <name>$PROJ_DIR$\Sources\BusRead.asm</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Sources\BusWrite.asm</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Sources\clic3.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Sources\Initialise.asm</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Sources\main1.c</name>
  </file>
</project>


